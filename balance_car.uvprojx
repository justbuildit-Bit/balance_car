# Keil uVision project balance_car.uvprojx, settings and files
target default (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=4 wLevel=2
  c misc: --no-multibyte-chars
  c include: .\std_periph_driver\inc;.\user;.\my_lib;.\my_lib\font;.\my_lib\font\.h;.\test
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/: main.c system_stm32f10x.c stm32f10x_it.h stm32f10x_it.c app_bat.c app_bat.h app_usart2.c app_usart2.h app_button.c app_button.h app_pwm.c app_pwm.h app_encoder.c app_encoder.h app_MPU6050.c app_MPU6050.h PID.c PID.h app_motor.c app_motor.h app_control.c app_control.h app_rc.c app_rc.h app_kalman.c app_kalman.h
  group startup
    ./startup/: startup_stm32f10x_md.s
  group std_periph_driver
    ./std_periph_driver/inc/: misc.h stm32f10x.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ./std_periph_driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group my_lib
    ./my_lib/: delay.h delay.c usart.h usart.c i2c.h i2c.c si2c.h si2c.c oled.h oled.c button.h button.c spi.h spi.c task.h qmath.h qmath.c
  group test
    ./test/: bat_test.c bat_test.h pwm_test.c pwm_test.h encoder_test.c encoder_test.h MPU6050_test.c MPU6050_test.h qmath_test.c qmath_test.h
